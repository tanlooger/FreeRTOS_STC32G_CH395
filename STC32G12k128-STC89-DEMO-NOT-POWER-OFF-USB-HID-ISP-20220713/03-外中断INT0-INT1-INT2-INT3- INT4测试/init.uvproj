# Keil uVision project init.uvproj, settings and files
target init (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: init +hex
  group Source
    ./: init.c
    ../COMM/: stc_usb_hid_32g.LIB
