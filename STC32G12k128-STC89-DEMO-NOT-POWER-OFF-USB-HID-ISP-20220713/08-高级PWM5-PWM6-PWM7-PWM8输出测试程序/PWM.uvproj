# Keil uVision project PWM.uvproj, settings and files
target PWM (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PWM +hex
  group Source
    ./: PWM.c
    ../COMM/: stc_usb_hid_32g.LIB
