# Keil uVision project timer.uvproj, settings and files
target timer (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: timer +hex
  group Source
    ./: timer.c
    ../COMM/: stc_usb_hid_32g.LIB
